v {xschem version=3.4.0 file_version=1.2}
G {}
